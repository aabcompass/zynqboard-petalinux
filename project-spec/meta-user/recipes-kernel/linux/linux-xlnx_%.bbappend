SRC_URI += " \
	  file://user_2020-01-21-12-39-00.cfg \
	  file://por-linux.patch \
	  "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

